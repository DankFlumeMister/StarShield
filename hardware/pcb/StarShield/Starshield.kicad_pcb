# Repository DankFlumeMister/StarShield

File README.md:

# StarShield

**一个开源、全自定义、面向新手教程的无线机械键盘。**

目标是一把 **95 键紧凑全尺寸**单体键盘：键盘本体经 **BLE** 连接一个 USB Dongle，
Dongle 插在主机上，从而获得接近 2.4GHz 的无线体验。硬件设计、固件与教程全部开放。

> ⚠️ **项目仍在设计阶段，尚无硬件实物。** 本 README 如实标注每一项的完成度，
> 未验证的内容不会写成已完成。

---

## 目标

- **95 键紧凑全尺寸**单体键盘（含独立小键盘与导航键簇）
- **无线优先**：Body（键盘本体）作为 BLE peripheral，Dongle 作为 BLE central
- **USB-C 有线备用**：充电 + 有线模式
- **ZMK Studio** 浏览器实时改键
- **Per-key RGB**：95 颗独立发光，组合键控制开关/亮度/颜色/灯效
- **硬件开源**，新手可复刻
- 控制器模块同时兼容 **nice!nano v2** 与 **SuperMini nRF52840**（低成本路线）

## 系统架构

```text
┌─────────────────────────────┐        ┌──────────────────┐      ┌────────┐
│        键盘 Body             │        │      Dongle      │      │  主机   │
│                             │        │                  │      │        │
│  nice!nano v2 (peripheral)  │──BLE──▶│ XIAO nRF52840    │─USB─▶│  PC    │
│   ├─ 95 键矩阵 6 行 × 18 列   │        │   (central)      │      │        │
│   │    ├─ 6 行直连 MCU       │        └──────────────────┘      └────────┘
│   │    └─ 18 列由 2×74HC595  │
│   ├─ BQ24072 充电 + 电源路径管理 │
│   ├─ 3000mAh LiPo（无断电开关）  │
│   └─ 95 颗 SK6812MINI-E + 门控   │
└─────────────────────────────┘
```

**关键技术选择**（完整理由见 `docs/adr/`）：

| 主题 | 选择 |
| --- | --- |
| 固件 | ZMK（基于 Zephyr RTOS） |
| 无线方案 | BLE Dongle（**非**原生 2.4GHz，见 [ADR-0001](docs/adr/0001-zmk-ble-dongle-over-native-2.4ghz.md)） |
| 矩阵驱动 | **2 颗 74HC595 级联**驱动 18 列（见 [ADR-0008](docs/adr/0008-matrix-via-74hc595-shift-register.md)） |
| 充电 | BQ24072，线性充电 + 电源路径管理，做在主 PCB |
| RGB 供电 | **电池直供**，不加 5V 升压（见 [ADR-0007](docs/adr/0007-rgb-powered-directly-from-battery.md)） |
| 许可 | CERN-OHL-S-2.0 |

---

## 当前状态

| 模块 | 状态 | 说明 |
| --- | --- | --- |
| 产品与硬件设计决策 | ✅ 已完成 | 11 条 ADR + 完整决策日志 |
| 键位几何 | ✅ 已核验 | 95 键、19.50u × 6.25u（371.5 × 119.1 mm） |
| 95 键矩阵分配 | ✅ 已完成 | 6 行 × 18 列，18 列达数学下界 |
| PCB 原理图（矩阵部分） | ✅ 已完成 | **网表校验 10 项全通过、ERC 0 error** |
| PCB 原理图（电源/RGB/控制板） | 🔴 未完成 | 拓扑与元件取值已定，待画图 |
| 固件配置 | 🟡 已写出 | shield 全套 + 95 键映射，**静态校验通过** |
| 固件编译验证 | ✅ **已通过** | GitHub Actions 用 ZMK v0.3.0 实跑 `west build`，产出可烧录的 `.uf2` |
| PCB 布局 / 外壳 / BOM / 教程 | 🔴 未开始 | |

### 已产出的设计文档

| 文档 | 内容 |
| --- | --- |
| [`docs/decisions.md`](docs/decisions.md) | 完整决策日志 |
| [`docs/adr/`](docs/adr/) | 架构决策记录 0001–0011 |
| [`docs/hardware-geometry.md`](docs/hardware-geometry.md) | 键位几何基准（含一次错误测量的教训） |
| [`docs/matrix-assignment.md`](docs/matrix-assignment.md) | 95 键矩阵行列分配 + 网表校验 |
| [`docs/matrix-folding-analysis.md`](docs/matrix-folding-analysis.md) | 为什么必须用移位寄存器（含引脚预算推导） |
| [`docs/zmk-kscan-alternatives.md`](docs/zmk-kscan-alternatives.md) | ZMK 全部 6 个 keyscan 驱动排查 |
| [`docs/power-architecture.md`](docs/power-architecture.md) | 电源树、电流预算、选型 |
| [`docs/bq24072-pinout.md`](docs/bq24072-pinout.md) | 充电 IC 引脚与元件取值 |
| [`docs/controller-and-battery-facts.md`](docs/controller-and-battery-facts.md) | 控制器/电池/JST 已核实事实 |
| [`firmware/README.md`](firmware/README.md) | 固件引脚分配权威表 + 踩坑记录 |

---

## 仓库结构

```text
.
├── docs/                     设计文档、决策记录、生成/校验脚本
│   ├── adr/                  架构决策记录 0001–0011
│   ├── _tools/               可复现的生成与校验脚本
│   └── _generated/           脚本产物
├── firmware/                 ZMK 固件配置
│   ├── build.yaml            构建矩阵
│   └── boards/shields/starshield/
├── hardware/
│   ├── pcb/
│   │   ├── StarShield/       KiCad 工程（95 键矩阵原理图）
│   │   └── TEST1/            练习工程
│   └── case/                 3D 打印外壳（待开始）
├── research/                 调研报告（结论性，逐条带来源）
├── sketch/                   键盘布局图（KLE 格式，几何唯一权威）
└── tutorials/                新手教程（待开始）
```

---

## 自己跑一遍

本项目全部设计产物由脚本生成，且**可复现**（重跑不会产生差异）。

```bash
# 需要：Node.js、Python 3、KiCad（命令行工具 kicad-cli）
node docs/_tools/matrix-assign.mjs      # 矩阵分配
node docs/_tools/gen_transform.mjs      # 键盘映射表 + 物理布局
node docs/_tools/gen_keymap.mjs         # 键位映射
python docs/_tools/gen_matrix_sch.py    # 生成 KiCad 原理图

# 校验
python docs/_tools/verify_netlist.py    # 网表电气校验（10 项）
python docs/_tools/verify_firmware.py   # 固件静态校验
```

> 若 `kicad-cli` 不在 PATH 上，可用环境变量指定：
> `export KICAD_CLI=/path/to/kicad-cli`

KiCad 工程：用 KiCad 打开 `hardware/pcb/StarShield/Starshield.kicad_pro`。

### 构建固件

固件由 CI 自动构建（ZMK 版本钉在 `firmware/west.yml` 的 `v0.3.0`，上游变更新不会悄悄破坏构建）。
**已实测通过**，产物为两个可烧录的 UF2：

| 文件 | 用途 |
| --- | --- |
| `starshield-body.uf2` | 键盘本体固件 |
| `starshield-settings-reset.uf2` | 清空设置（刷完再刷本体固件，用于恢复出厂状态） |

获取方式：进入 [Actions](https://github.com/DankFlumeMister/StarShield/actions/workflows/build.yml)
→ 选最新一次成功的 run → 页面底部 **Artifacts** → 下载 `starshield-firmware`。

> ⚠️ 这些 UF2 **尚未在真实硬件上烧录验证过** —— 能编译不等于能用。
> 等 PCB 打样后会补上实测记录。

自己触发一次构建：Actions 页面 → **Run workflow**（工作流带 `workflow_dispatch`）。

---

## 已知限制（重要，请勿误读完成度）

- **没有任何硬件实物。** 所有结论均基于设计推导、厂商 datasheet 与仿真级校验。
- **固件已能编译出 `.uf2`，但从未烧进真板子跑过。** 编译通过只说明配置自洽，
  不代表按键定义、RGB 时序、电源门控在实物上正确 —— 这些都必须等 PCB 打样后实测。
- **原理图只画了矩阵部分**，电源与 RGB 子图尚未绘制。
- **引脚分配的机械尺寸未用实物核对。** nice!nano 排针的 pitch 与每边引脚数
  来自 ZMK 官方设备树定义与 Pro Micro 标准旁证，**投板前必须用实物卡尺复核**。
- 外壳必须分件打印：键区宽 **371.5 mm**，超过常见 256 mm 打印床。
- 以下三项**已有推荐方案但尚未确认**（详见 [ADR-0009](docs/adr/0009-three-position-mode-switch.md)、[ADR-0010](docs/adr/0010-battery-cutoff-strategy.md)）：
  - **连接模式开关**：三档拨片（2.4G / 蓝牙 / 有线），单刀 `SP3T`。
    方案用 ZMK 上游原生机制（`toggle-mode` + sideband behaviors），**键盘侧零自定义固件**；
    但 Dongle 必须是「BLE HID 主机」形态，**其固件不是 ZMK，是一块独立的开发量**。
  - **不设电池断电开关**：电池始终接通，「关机」= 拨到有线档 + 拔掉 USB 线，
    再由 ZMK 深睡接手；长期存放拔电池插头。
    这是跟随成熟三模产品（Keychron 等）的做法，也回避了「小开关要扛 2.4 A」的难题。
  - **RGB 门控关断拓扑**：电池满电时 3.3 V GPIO 无法保证关断源极在 4.2 V 轨的高边 PMOS，
    需加一级 NMOS 反相（`GPIO_ACTIVE_HIGH`）。⚠️ 该失效的量级未经实测，标记为未核实。

---

## 参与

项目仍在早期。如果你对以下方向感兴趣，欢迎开 issue 讨论：

- 95 键布局的定位板/外壳设计
- 电源子图（BQ24072 充电 + 电源路径）复核
- 实物打样后的固件实测（矩阵扫描、RGB、电源门控、休眠电流）

## 许可证

本项目采用 **CERN-OHL-S-2.0**（强互惠开源硬件许可证），全文见 [LICENSE](LICENSE)。

任何人可商业使用、修改和分发本设计，但**衍生产品必须同样以 CERN-OHL-S-2.0 开源，
并公开完整设计文件**。

## KiCad design hardware/pcb/StarShield/Starshield.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34: 1N4148W; D_SOD-123
SW1: Esc; SW_MX_Hotswap_Optional_1.00u
SW2: FN; SW_MX_Hotswap_Optional_1.00u
SW3: Num Lock; SW_MX_Hotswap_Optional_1.00u
SW4: F1; SW_MX_Hotswap_Optional_1.00u
SW5: F2; SW_MX_Hotswap_Optional_1.00u
SW6: F3; SW_MX_Hotswap_Optional_1.00u
SW7: F4; SW_MX_Hotswap_Optional_1.00u
SW8: F5; SW_MX_Hotswap_Optional_1.00u
SW9: F6; SW_MX_Hotswap_Optional_1.00u
SW10: F7; SW_MX_Hotswap_Optional_1.00u
SW11: F8; SW_MX_Hotswap_Optional_1.00u
SW12: F9; SW_MX_Hotswap_Optional_1.00u
SW13: F10; SW_MX_Hotswap_Optional_1.00u
SW14: F11; SW_MX_Hotswap_Optional_1.00u
SW15: F12; SW_MX_Hotswap_Optional_1.00u
SW16: Delete; SW_MX_Hotswap_Optional_1.00u
SW17: /; SW_MX_Hotswap_Optional_1.00u
SW18: *; SW_MX_Hotswap_Optional_1.00u
SW19: -; SW_MX_Hotswap_Optional_1.00u
SW20: +; SW_MX_Hotswap_Optional_1.00u
SW21: ~/`; SW_MX_Hotswap_Optional_1.00u
SW22: !/1; SW_MX_Hotswap_Optional_1.00u
SW23: @/2; SW_MX_Hotswap_Optional_1.00u
SW24: #/3; SW_MX_Hotswap_Optional_1.00u
SW25: $/4; SW_MX_Hotswap_Optional_1.00u
SW26: %/5; SW_MX_Hotswap_Optional_1.00u
SW27: ^/6; SW_MX_Hotswap_Optional_1.00u
SW28: &/7; SW_MX_Hotswap_Optional_1.00u
SW29: */8; SW_MX_Hotswap_Optional_1.00u
SW30: (/9; SW_MX_Hotswap_Optional_1.00u
SW31: )/0; SW_MX_Hotswap_Optional_1.00u
SW32: _/-; SW_MX_Hotswap_Optional_1.00u
SW33: +/=; SW_MX_Hotswap_Optional_1.00u
SW34: Back Space; SW_MX_Hotswap_Optional_2.00u

Connections:
COL0: D1.1 (K), D17.1 (K); also elsewhere on the board
COL1: D2.1 (K), D18.1 (K); also elsewhere on the board
COL2: D3.1 (K), D19.1 (K); also elsewhere on the board
COL3: D4.1 (K), D20.1 (K); also elsewhere on the board
COL4: D5.1 (K), D21.1 (K); also elsewhere on the board
COL5: D6.1 (K), D22.1 (K); also elsewhere on the board
COL6: D7.1 (K), D23.1 (K); also elsewhere on the board
COL7: D8.1 (K), D24.1 (K); also elsewhere on the board
COL8: D9.1 (K), D25.1 (K); also elsewhere on the board
COL9: D10.1 (K), D26.1 (K); also elsewhere on the board
COL10: D11.1 (K), D27.1 (K); also elsewhere on the board
COL11: D12.1 (K), D28.1 (K); also elsewhere on the board
COL12: D13.1 (K), D29.1 (K); also elsewhere on the board
COL13: D14.1 (K), D30.1 (K); also elsewhere on the board
COL14: D15.1 (K), D31.1 (K); also elsewhere on the board
COL15: D16.1 (K), D32.1 (K); also elsewhere on the board
COL16: D33.1 (K); also elsewhere on the board
COL17: D34.1 (K); also elsewhere on the board
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
ROW0: SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1, SW10.1, SW11.1, SW12.1, SW13.1, SW14.1, SW15.1, SW16.1; also elsewhere on the board
ROW1: SW17.1, SW18.1, SW19.1, SW20.1, SW21.1, SW22.1, SW23.1, SW24.1, SW25.1, SW26.1, SW27.1, SW28.1, SW29.1, SW30.1, SW31.1, SW32.1, SW33.1, SW34.1; also elsewhere on the board

Parts:
D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67: 1N4148W; D_SOD-123
SW35: Delete; SW_MX_Hotswap_Optional_2.00u_Vertical
SW36: 7/Home; SW_MX_Hotswap_Optional_1.00u
SW37: 8/↑; SW_MX_Hotswap_Optional_1.00u
SW38: 9/PgUp; SW_MX_Hotswap_Optional_1.00u
SW39: Tab; SW_MX_Hotswap_Optional_1.50u
SW40: Q; SW_MX_Hotswap_Optional_1.00u
SW41: W; SW_MX_Hotswap_Optional_1.00u
SW42: E; SW_MX_Hotswap_Optional_1.00u
SW43: R; SW_MX_Hotswap_Optional_1.00u
SW44: T; SW_MX_Hotswap_Optional_1.00u
SW45: Y; SW_MX_Hotswap_Optional_1.00u
SW46: U; SW_MX_Hotswap_Optional_1.00u
SW47: I; SW_MX_Hotswap_Optional_1.00u
SW48: O; SW_MX_Hotswap_Optional_1.00u
SW49: P; SW_MX_Hotswap_Optional_1.00u
SW50: {/[; SW_MX_Hotswap_Optional_1.00u
SW51: }/]; SW_MX_Hotswap_Optional_1.00u
SW52: Enter; SW_MX_Hotswap_Optional_2.25u
SW53: 4/←; SW_MX_Hotswap_Optional_1.00u
SW54: 5; SW_MX_Hotswap_Optional_1.00u
SW55: 6/→; SW_MX_Hotswap_Optional_1.00u
SW56: Caps Lock; SW_MX_Hotswap_Optional_1.75u
SW57: A; SW_MX_Hotswap_Optional_1.00u
SW58: S; SW_MX_Hotswap_Optional_1.00u
SW59: D; SW_MX_Hotswap_Optional_1.00u
SW60: F; SW_MX_Hotswap_Optional_1.00u
SW61: G; SW_MX_Hotswap_Optional_1.00u
SW62: H; SW_MX_Hotswap_Optional_1.00u
SW63: J; SW_MX_Hotswap_Optional_1.00u
SW64: K; SW_MX_Hotswap_Optional_1.00u
SW65: L; SW_MX_Hotswap_Optional_1.00u
SW66: :/;; SW_MX_Hotswap_Optional_1.00u
SW67: "/'; SW_MX_Hotswap_Optional_1.00u

Connections:
COL0: D35.1 (K), D53.1 (K); also elsewhere on the board
COL1: D36.1 (K), D54.1 (K); also elsewhere on the board
COL2: D37.1 (K), D55.1 (K); also elsewhere on the board
COL3: D38.1 (K), D56.1 (K); also elsewhere on the board
COL4: D39.1 (K), D57.1 (K); also elsewhere on the board
COL5: D40.1 (K), D58.1 (K); also elsewhere on the board
COL6: D41.1 (K), D59.1 (K); also elsewhere on the board
COL7: D42.1 (K), D60.1 (K); also elsewhere on the board
COL8: D43.1 (K), D61.1 (K); also elsewhere on the board
COL9: D44.1 (K), D62.1 (K); also elsewhere on the board
COL10: D45.1 (K), D63.1 (K); also elsewhere on the board
COL11: D46.1 (K), D64.1 (K); also elsewhere on the board
COL12: D47.1 (K), D65.1 (K); also elsewhere on the board
COL13: D48.1 (K), D66.1 (K); also elsewhere on the board
COL14: D49.1 (K), D67.1 (K); also elsewhere on the board
COL15: D50.1 (K); also elsewhere on the board
COL16: D51.1 (K); also elsewhere on the board
COL17: D52.1 (K); also elsewhere on the board
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: D54.2 (A), SW54.2
unnamed: D55.2 (A), SW55.2
unnamed: D56.2 (A), SW56.2
unnamed: D57.2 (A), SW57.2
unnamed: D58.2 (A), SW58.2
unnamed: D59.2 (A), SW59.2
unnamed: D60.2 (A), SW60.2
unnamed: D61.2 (A), SW61.2
unnamed: D62.2 (A), SW62.2
unnamed: D63.2 (A), SW63.2
unnamed: D64.2 (A), SW64.2
unnamed: D65.2 (A), SW65.2
unnamed: D66.2 (A), SW66.2
unnamed: D67.2 (A), SW67.2
ROW2: SW35.1, SW36.1, SW37.1, SW38.1, SW39.1, SW40.1, SW41.1, SW42.1, SW43.1, SW44.1, SW45.1, SW46.1, SW47.1, SW48.1, SW49.1, SW50.1, SW51.1, SW52.1; also elsewhere on the board
ROW3: SW53.1, SW54.1, SW55.1, SW56.1, SW57.1, SW58.1, SW59.1, SW60.1, SW61.1, SW62.1, SW63.1, SW64.1, SW65.1, SW66.1, SW67.1; also elsewhere on the board

Parts:
D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95: 1N4148W; D_SOD-123
SW68: Enter; SW_MX_Hotswap_Optional_2.00u_Vertical
SW69: 1/End; SW_MX_Hotswap_Optional_1.00u
SW70: 2/↓; SW_MX_Hotswap_Optional_1.00u
SW71: 3/PgDn; SW_MX_Hotswap_Optional_1.00u
SW72: Shift; SW_MX_Hotswap_Optional_2.25u
SW73: Z; SW_MX_Hotswap_Optional_1.00u
SW74: X; SW_MX_Hotswap_Optional_1.00u
SW75: C; SW_MX_Hotswap_Optional_1.00u
SW76: V; SW_MX_Hotswap_Optional_1.00u
SW77: B; SW_MX_Hotswap_Optional_1.00u
SW78: N; SW_MX_Hotswap_Optional_1.00u
SW79: M; SW_MX_Hotswap_Optional_1.00u
SW80: </,; SW_MX_Hotswap_Optional_1.00u
SW81: >/.; SW_MX_Hotswap_Optional_1.00u
SW82: ?//; SW_MX_Hotswap_Optional_1.00u
SW83: ↑; SW_MX_Hotswap_Optional_1.00u
SW84: Shift; SW_MX_Hotswap_Optional_1.75u
SW85: 0/Ins; SW_MX_Hotswap_Optional_1.50u
SW86: ./Del; SW_MX_Hotswap_Optional_1.50u
SW87: Ctrl; SW_MX_Hotswap_Optional_1.25u
SW88: Win; SW_MX_Hotswap_Optional_1.25u
SW89: Alt; SW_MX_Hotswap_Optional_1.25u
SW90: Space; SW_MX_Hotswap_Optional_6.25u
SW91: |/\; SW_MX_Hotswap_Optional_1.00u
SW92: ←; SW_MX_Hotswap_Optional_1.00u
SW93: ↓; SW_MX_Hotswap_Optional_1.00u
SW94: →; SW_MX_Hotswap_Optional_1.00u
SW95: Ctrl; SW_MX_Hotswap_Optional_1.00u

Connections:
COL0: D68.1 (K), D85.1 (K); also elsewhere on the board
COL1: D69.1 (K), D86.1 (K); also elsewhere on the board
COL2: D70.1 (K), D87.1 (K); also elsewhere on the board
COL3: D71.1 (K), D88.1 (K); also elsewhere on the board
COL4: D72.1 (K), D89.1 (K); also elsewhere on the board
COL5: D73.1 (K), D90.1 (K); also elsewhere on the board
COL6: D74.1 (K), D91.1 (K); also elsewhere on the board
COL7: D75.1 (K), D92.1 (K); also elsewhere on the board
COL8: D76.1 (K), D93.1 (K); also elsewhere on the board
COL9: D77.1 (K), D94.1 (K); also elsewhere on the board
COL10: D78.1 (K), D95.1 (K); also elsewhere on the board
COL11: D79.1 (K); also elsewhere on the board
COL12: D80.1 (K); also elsewhere on the board
COL13: D81.1 (K); also elsewhere on the board
COL14: D82.1 (K); also elsewhere on the board
COL15: D83.1 (K); also elsewhere on the board
COL16: D84.1 (K); also elsewhere on the board
unnamed: D68.2 (A), SW68.2
unnamed: D69.2 (A), SW69.2
unnamed: D70.2 (A), SW70.2
unnamed: D71.2 (A), SW71.2
unnamed: D72.2 (A), SW72.2
unnamed: D73.2 (A), SW73.2
unnamed: D74.2 (A), SW74.2
unnamed: D75.2 (A), SW75.2
unnamed: D76.2 (A), SW76.2
unnamed: D77.2 (A), SW77.2
unnamed: D78.2 (A), SW78.2
unnamed: D79.2 (A), SW79.2
unnamed: D80.2 (A), SW80.2
unnamed: D81.2 (A), SW81.2
unnamed: D82.2 (A), SW82.2
unnamed: D83.2 (A), SW83.2
unnamed: D84.2 (A), SW84.2
unnamed: D85.2 (A), SW85.2
unnamed: D86.2 (A), SW86.2
unnamed: D87.2 (A), SW87.2
unnamed: D88.2 (A), SW88.2
unnamed: D89.2 (A), SW89.2
unnamed: D90.2 (A), SW90.2
unnamed: D91.2 (A), SW91.2
unnamed: D92.2 (A), SW92.2
unnamed: D93.2 (A), SW93.2
unnamed: D94.2 (A), SW94.2
unnamed: D95.2 (A), SW95.2
ROW4: SW68.1, SW69.1, SW70.1, SW71.1, SW72.1, SW73.1, SW74.1, SW75.1, SW76.1, SW77.1, SW78.1, SW79.1, SW80.1, SW81.1, SW82.1, SW83.1, SW84.1; also elsewhere on the board
ROW5: SW85.1, SW86.1, SW87.1, SW88.1, SW89.1, SW90.1, SW91.1, SW92.1, SW93.1, SW94.1, SW95.1; also elsewhere on the board

Parts:
C1: 1uF; C_0603_1608Metric
C2, C3: 4.7uF; C_0603_1608Metric
D96: RED; LED_0603_1608Metric
F1: 2A; Fuse_1812_4532Metric; MPN MF-MSMF200; LCSC ❓待补（BOM 阶段）
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN TYPE-C-31-M-12; LCSC C165948
J2: B2B-PH-K-S; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical; MPN B2B-PH-K-S(LF)(SN); LCSC C131337
Q1: AO3401A; SOT-23; MPN AO3401A
Q2: 2N7002; SOT-23; MPN 2N7002
R1, R2: 5.1k; R_0603_1608Metric
R3: 1.6k; R_0603_1608Metric
R4: 887; R_0603_1608Metric
R5, R7, R9: 10k; R_0603_1608Metric
R6: 1.5k; R_0603_1608Metric
R8: 100; R_0603_1608Metric
U1: BQ24072RGT; VQFN-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm_ThermalVias; MPN BQ24072RGT

Connections:
GND: C1.2, C2.2, C3.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.2, Q2.2 (S), R1.2, R2.2, R3.2, R4.2, R5.2, R9.2, U1.4 (~CE), U1.6 (EN1), U1.8 (VSS), U1.14 (TMR), U1.15 (TD), U1.17 (VSS); also elsewhere on the board
OUT: C2.1, Q1.2 (S), R6.1, R7.1, U1.5 (EN2), U1.10 (OUT), U1.11 (OUT)
RGB_PWR_EN: R8.1; also elsewhere on the board
VBAT: C3.1, J2.1, U1.2 (BAT), U1.3 (BAT); also elsewhere on the board
VBUS: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
VLED: Q1.3 (D); also elsewhere on the board
电源 / 充电 / RGB 门控/CC1: J1.A5 (CC1), R1.1
电源 / 充电 / RGB 门控/CC2: J1.B5 (CC2), R2.1
电源 / 充电 / RGB 门控/CHG_LED_A: D96.2 (A), R6.2
电源 / 充电 / RGB 门控/ILIM: R3.1, U1.12 (ILIM)
电源 / 充电 / RGB 门控/ISET: R4.1, U1.16 (ISET)
电源 / 充电 / RGB 门控/Q1_G: Q1.1 (G), Q2.3 (D), R7.2
电源 / 充电 / RGB 门控/Q2_G: Q2.1 (G), R8.2, R9.1
电源 / 充电 / RGB 门控/TS: R5.1, U1.1 (TS)
电源 / 充电 / RGB 门控/VCHG_IN: C1.1, F1.2, U1.13 (IN)
电源 / 充电 / RGB 门控/nCHG: D96.1 (K), U1.9 (~CHG)

Notes on the sheet:
StarShield 电源子图 —— 由 docs/_tools/gen_power_sch.py 自动生成，请勿手改；改电路请改 docs/_tools/power_design.py。依据：docs/power-architecture.md / docs/bq24072-pinout.md
【取值依据】U1=BQ24072RGT。电池 = 2x5000mAh 并联（1S2P 共用一块 PCM，共 10000mAh）。ICHG = 890 / R_ISET = 1.0 A（=0.10C @10000mAh）；EN2=1 且 EN1=0 选 ILIM 档，输入限流 = 1610 / R_ILIM = 1.0 A；~CE 接 VSS 常开；TD 接 VSS 使能充电终止；TS 经 10k 到 VSS 禁用温度监测；TMR 接 VSS 禁用所有安全定时器（10h 仍超定时器 typ 9.6h）。VBUS 经 F1（2A hold 自恢复保险丝，1812）后进 IN。注意：输入取 1.0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
【电源路径】重载（VLED 灯轨等）必须接 OUT 而不是 BAT（ADR-0002）。OUT 稳压到 VBAT + 225 mV，满电时 OUT 约 4.4 V。VLED 由 OUT 经 Q1 门控 —— 属电池直供，不含任何升压（ADR-0007 / ADR-0005）。⚠️ 2026-09-19 例外：nice!nano 模块的 B+/RAW 改接 VBAT（不再接 OUT）—— 因为模块自带充电器要能把电流送进电池（插模块口即充电）；模块本身电流很小（休眠 20uA 级），不影响电源路径的意义
【走线电流约束】VLED 按 2-3 A 走线。但 BQ24072 的 OUT 短路保护阈值 VO(SC2) = 250 mV，VBAT - VOUT 超过该值并持续 250 us 即切断 OUT 并在 60 ms 后重试 => 固件必须把 RGB 峰值限制在约 1 A（docs/power-architecture.md 5.2）
【电池与连接器约束】J2 为 JST-PH 2.0，额定 2 A（限 AWG #24 条件）。RGB 全亮峰值约 2.4 A 超过该额定，pigtail 请指定 AWG #24。电池须为 1S2P 一体化包（两块 5000mAh 共用一块 PCM），不可用两块各自带保护板的电芯直接并联（会互充，且两块保护板阈值失配）；PCM 的过流保护阈值必须大于 2A，否则 RGB 全亮会触发保护断电
【门控拓扑 C（ADR-0005，照抄 kurtis-lew/Conejo）】Q1 的 S 必须接电源轨 OUT、D 接负载轨 VLED —— P-MOS 体二极管阳极在 D，反接会让 LED 轨经体二极管常通，门控失效。ZMK 侧 ext-power 用 GPIO_ACTIVE_HIGH。控制链：GPIO 高 -> Q2 导通 -> Q1 栅极拉低 -> VLED 得电
【本版留空 / 未决项】USB-C 的 D+ D- SBU1 SBU2 全部 NC（J1 只做充电 —— nRF52840 的 USB 是独立专用引脚，nice!nano 排针上无引出）；U1 的 ~PGOOD 悬空（预留测试点）。F1 已按降额曲线定案为 2A hold 的 1812 自恢复保险丝（1.5A 档在 60°C 降额后仅 1.00A，等于工作电流，会误断）。详见 docs/power-architecture.md 第 6 节待办
【投板后必须实测】1) AO3401A 在 Vgs 约 -0.9 V 时的关断漏电（标 UNVERIFIED）2) RGB 峰值电流下 OUT 压降是否仍在 250 mV 以内 3) 深睡整机电流（目标约 20 uA）4) TMR 接 VSS 后充电能否正常走到 4.2 V 并靠终止电流判据结束（安全定时器已禁用）

Parts:
C4, C5, C6: 100nF; C_0603_1608Metric
J3A: nice!nano v2 左列 (孔 1-13); PinSocket_1x13_P2.54mm_Vertical; MPN Mill-Max 315-43-113-41-001000 ❓待核
J3B: nice!nano v2 右列 (孔 1-13); PinSocket_1x13_P2.54mm_Vertical; MPN Mill-Max 315-43-113-41-001000 ❓待核
SW96: PCM13 (SP3T); SW_SP3T_PCM13; MPN PCM13SMTR; LCSC ❓待补（BOM 阶段）
U2, U3, U4: 74HC595; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
COL0: U2.15 (QA); also elsewhere on the board
COL1: U2.1 (QB); also elsewhere on the board
COL2: U2.2 (QC); also elsewhere on the board
COL3: U2.3 (QD); also elsewhere on the board
COL4: U2.4 (QE); also elsewhere on the board
COL5: U2.5 (QF); also elsewhere on the board
COL6: U2.6 (QG); also elsewhere on the board
COL7: U2.7 (QH); also elsewhere on the board
COL8: U3.15 (QA); also elsewhere on the board
COL9: U3.1 (QB); also elsewhere on the board
COL10: U3.2 (QC); also elsewhere on the board
COL11: U3.3 (QD); also elsewhere on the board
COL12: U3.4 (QE); also elsewhere on the board
COL13: U3.5 (QF); also elsewhere on the board
COL14: U3.6 (QG); also elsewhere on the board
COL15: U3.7 (QH); also elsewhere on the board
COL16: U4.15 (QA); also elsewhere on the board
COL17: U4.1 (QB); also elsewhere on the board
GND: C4.2, C5.2, C6.2, J3A.1, J3A.4, J3A.5, J3B.3, SW96.3, U2.8 (GND), U2.13 (~OE), U3.8 (GND), U3.13 (~OE), U4.8 (GND), U4.13 (~OE); also elsewhere on the board
LED_DIN: J3A.2; also elsewhere on the board
RGB_PWR_EN: J3B.13; also elsewhere on the board
ROW0: J3A.8; also elsewhere on the board
ROW1: J3A.9; also elsewhere on the board
ROW2: J3A.10; also elsewhere on the board
ROW3: J3A.11; also elsewhere on the board
ROW4: J3A.13; also elsewhere on the board
ROW5: J3A.12; also elsewhere on the board
VBAT: J3B.1, J3B.2; also elsewhere on the board
VCC: C4.1, C5.1, C6.1, J3B.5, U2.10 (~SRCLR), U2.16 (VCC), U3.10 (~SRCLR), U3.16 (VCC), U4.10 (~SRCLR), U4.16 (VCC)
控制板 / MCU / 595 / 模式开关/595_MOSI: J3B.12, U2.14 (SER)
控制板 / MCU / 595 / 模式开关/595_RCLK: J3B.8, U2.12 (RCLK), U3.12 (RCLK), U4.12 (RCLK)
控制板 / MCU / 595 / 模式开关/595_SCK: J3B.10, U2.11 (SRCLK), U3.11 (SRCLK), U4.11 (SRCLK)
控制板 / MCU / 595 / 模式开关/CASCADE1: U2.9 (QH'), U3.14 (SER)
控制板 / MCU / 595 / 模式开关/CASCADE2: U3.9 (QH'), U4.14 (SER)
控制板 / MCU / 595 / 模式开关/MODE0: J3A.6, SW96.1
控制板 / MCU / 595 / 模式开关/MODE1: J3B.11, SW96.2
控制板 / MCU / 595 / 模式开关/MODE2: J3B.9, SW96.4

Notes on the sheet:
StarShield 控制板子图 —— 由 docs/_tools/gen_control_sch.py 自动生成，请勿手改；改电路请改 docs/_tools/control_design.py。依据：docs/adr/0008(修订) / 0009 / docs/controller-and-battery-facts.md / ZMK arduino_pro_micro_pins.dtsi
【排针映射】J3A.n / J3B.n = nice!nano v2 **实物孔位序号（自 USB 端起，每排 13 孔）**。2026-09-19 B6 实物核对 + 官方 pinout 图确认每排 13 孔（比 Pro Micro 多 1 孔，多在 USB 端）；原 1x12 映射已作废。D 编号 ↔ GPIO 仍依 ZMK arduino_pro_micro_pins.dtsi，与孔位序号无关。逐孔映射表见 docs/nice-nano-physical-verification.md §6.2
【595 级联与位序】3 颗 74HC595（2026-09-18 修订，原 2 颗无法驱动 18 列 —— bit16/17 会被推出链尾）。位序：bit0..7 = U2.QA..QH = COL0..7；bit8..15 = U3 = COL8..15；bit16..17 = U4.QA/QB = COL16/17。~SRCLR 接 VCC（不复位）、~OE 接 GND（输出常使能）。位序依据 ZMK gpio_595.c：SPI MSB first，先移出的位最终在链尾
【三档开关】SP3T PCM13，公共端(pin3)接 GND，三个掷点接 MODE0/1/2。ZMK 用 toggle-mode + sideband 读取（GPIO_ACTIVE_LOW，DT 不写 pull —— 驱动管理）。档 0 = 有线（USB 输出）；档 1 = 蓝牙直连主机（配对位 0）；档 2 = 2.4G（配对位 1 连 Dongle）。开关 GPIO 定案 D2(P0.17) / D14(P1.11) / D18(P1.15)：保留 D0(UART 语义)、D3(普通余量)、D20/D21(ADC 余量)
【供电】J3B.1/2(B+/RAW) 接 **VBAT 电池节点**（2026-09-19 方案① 改接，原为 OUT）—— 如此插模块口即由模块自带充电器给电池充电（有线模式也充电）。nice!nano 板载稳压后输出 VCC(孔 5) 3.3V，给 3 颗 595 供电（负载轻，远低于 VCC 能力）。WS2812 供电走 VLED（电源子图 Q1 门控后的 LED 轨），不在本子图 —— 见 RGB 子图(M5)
【与其它子图的接口】全局标签同名即相连：OUT/VLED/RGB_PWR_EN（电源子图）、ROW0..5 / COL0..17（矩阵子图，2026-09-18 起矩阵侧也是全局标签）、LED_DIN（RGB 子图，尚未绘制 ⇒ 本图 ERC 的 isolated warning 属已知待办）、GND（电源符号）
【投板前核对】1) nice!nano 排针 pitch/脚数已由 B6 实物核对（每排 13 孔，已改 1x13）2) PCM13 封装 pad 与符号掷点对应（B3/B4）3) J3A.12/13 = ROW5/ROW4 的交错顺序与 overlay row-gpios 一一对应（已按 overlay 核实，但 PCB 布局时仍需复核）4) 排针针径与母座孔径、第五项：USB 口伸出量决定外壳开孔
