# Repository DankFlumeMister/StarShield (continued)

## KiCad design hardware/pcb/StarShield/Starshield.kicad_pcb (continued)

Parts:
LED1: Esc; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED2: FN; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED3: Num Lock; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED4: F1; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED5: F2; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED6: F3; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED7: F4; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED8: F5; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED9: F6; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED10: F7; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED11: F8; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED12: F9; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED13: F10; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED14: F11; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED15: F12; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED16, LED35: Delete; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED17: /; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED18: *; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED19: -; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED20: +; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED21: ~/`; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED22: !/1; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED23: @/2; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED24: #/3; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED25: $/4; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED26: %/5; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED27: ^/6; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED28: &/7; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED29: */8; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED30: (/9; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED31: )/0; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED32: _/-; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED33: +/=; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED34: Back Space; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED36: 7/Home; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED37: 8/↑; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED38: 9/PgUp; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED39: Tab; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED40: Q; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED41: W; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED42: E; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED43: R; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED44: T; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED45: Y; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED46: U; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED47: I; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED48: O; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED49: P; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED50: {/[; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED51: }/]; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED52, LED68: Enter; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED53: 4/←; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED54: 5; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED55: 6/→; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED56: Caps Lock; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED57: A; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED58: S; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED59: D; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED60: F; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED61: G; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED62: H; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED63: J; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED64: K; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED65: L; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED66: :/;; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED67: "/'; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED69: 1/End; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED70: 2/↓; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED71: 3/PgDn; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED72, LED84: Shift; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED73: Z; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED74: X; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED75: C; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED76: V; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED77: B; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED78: N; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED79: M; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED80: </,; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED81: >/.; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED82: ?//; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED83: ↑; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED85: 0/Ins; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED86: ./Del; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED87, LED95: Ctrl; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED88: Win; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED89: Alt; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED90: Space; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED91: |/\; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED92: ←; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED93: ↓; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201
LED94: →; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm; MPN SK6812MINI-E; LCSC C5149201

Connections:
GND: LED1.1 (VSS), LED2.1 (VSS), LED3.1 (VSS), LED4.1 (VSS), LED5.1 (VSS), LED6.1 (VSS), LED7.1 (VSS), LED8.1 (VSS), LED9.1 (VSS), LED10.1 (VSS), LED11.1 (VSS), LED12.1 (VSS), LED13.1 (VSS), LED14.1 (VSS), LED15.1 (VSS), LED16.1 (VSS), LED17.1 (VSS), LED18.1 (VSS), LED19.1 (VSS), LED20.1 (VSS), LED21.1 (VSS), LED22.1 (VSS), LED23.1 (VSS), LED24.1 (VSS), LED25.1 (VSS), LED26.1 (VSS), LED27.1 (VSS), LED28.1 (VSS), LED29.1 (VSS), LED30.1 (VSS), LED31.1 (VSS), LED32.1 (VSS), LED33.1 (VSS), LED34.1 (VSS), LED35.1 (VSS), LED36.1 (VSS), LED37.1 (VSS), LED38.1 (VSS), LED39.1 (VSS), LED40.1 (VSS), LED41.1 (VSS), LED42.1 (VSS), LED43.1 (VSS), LED44.1 (VSS), LED45.1 (VSS), LED46.1 (VSS), LED47.1 (VSS), LED48.1 (VSS), LED49.1 (VSS), LED50.1 (VSS), LED51.1 (VSS), LED52.1 (VSS), LED53.1 (VSS), LED54.1 (VSS), LED55.1 (VSS), LED56.1 (VSS), LED57.1 (VSS), LED58.1 (VSS), LED59.1 (VSS), LED60.1 (VSS), LED61.1 (VSS), LED62.1 (VSS), LED63.1 (VSS), LED64.1 (VSS), LED65.1 (VSS), LED66.1 (VSS), LED67.1 (VSS), LED68.1 (VSS), LED69.1 (VSS), LED70.1 (VSS), LED71.1 (VSS), LED72.1 (VSS), LED73.1 (VSS), LED74.1 (VSS), LED75.1 (VSS), LED76.1 (VSS), LED77.1 (VSS), LED78.1 (VSS), LED79.1 (VSS), LED80.1 (VSS), LED81.1 (VSS), LED82.1 (VSS), LED83.1 (VSS), LED84.1 (VSS), LED85.1 (VSS), LED86.1 (VSS), LED87.1 (VSS), LED88.1 (VSS), LED89.1 (VSS), LED90.1 (VSS), LED91.1 (VSS), LED92.1 (VSS), LED93.1 (VSS), LED94.1 (VSS), LED95.1 (VSS); also elsewhere on the board
LED_DIN: LED1.2 (DIN); also elsewhere on the board
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_2: LED1.4 (DOUT), LED2.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_3: LED2.4 (DOUT), LED3.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_4: LED3.4 (DOUT), LED4.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_5: LED4.4 (DOUT), LED5.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_6: LED5.4 (DOUT), LED6.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_7: LED6.4 (DOUT), LED7.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_8: LED7.4 (DOUT), LED8.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_9: LED8.4 (DOUT), LED9.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_10: LED9.4 (DOUT), LED10.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_11: LED10.4 (DOUT), LED11.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_12: LED11.4 (DOUT), LED12.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_13: LED12.4 (DOUT), LED13.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_14: LED13.4 (DOUT), LED14.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_15: LED14.4 (DOUT), LED15.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_16: LED15.4 (DOUT), LED16.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_17: LED16.4 (DOUT), LED17.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_18: LED17.4 (DOUT), LED18.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_19: LED18.4 (DOUT), LED19.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_20: LED19.4 (DOUT), LED20.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_21: LED20.4 (DOUT), LED21.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_22: LED21.4 (DOUT), LED22.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_23: LED22.4 (DOUT), LED23.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_24: LED23.4 (DOUT), LED24.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_25: LED24.4 (DOUT), LED25.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_26: LED25.4 (DOUT), LED26.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_27: LED26.4 (DOUT), LED27.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_28: LED27.4 (DOUT), LED28.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_29: LED28.4 (DOUT), LED29.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_30: LED29.4 (DOUT), LED30.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_31: LED30.4 (DOUT), LED31.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_32: LED31.4 (DOUT), LED32.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_33: LED32.4 (DOUT), LED33.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_34: LED33.4 (DOUT), LED34.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_35: LED34.4 (DOUT), LED35.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_36: LED35.4 (DOUT), LED36.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_37: LED36.4 (DOUT), LED37.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_38: LED37.4 (DOUT), LED38.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_39: LED38.4 (DOUT), LED39.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_40: LED39.4 (DOUT), LED40.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_41: LED40.4 (DOUT), LED41.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_42: LED41.4 (DOUT), LED42.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_43: LED42.4 (DOUT), LED43.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_44: LED43.4 (DOUT), LED44.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_45: LED44.4 (DOUT), LED45.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_46: LED45.4 (DOUT), LED46.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_47: LED46.4 (DOUT), LED47.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_48: LED47.4 (DOUT), LED48.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_49: LED48.4 (DOUT), LED49.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_50: LED49.4 (DOUT), LED50.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_51: LED50.4 (DOUT), LED51.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_52: LED51.4 (DOUT), LED52.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_53: LED52.4 (DOUT), LED53.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_54: LED53.4 (DOUT), LED54.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_55: LED54.4 (DOUT), LED55.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_56: LED55.4 (DOUT), LED56.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_57: LED56.4 (DOUT), LED57.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_58: LED57.4 (DOUT), LED58.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_59: LED58.4 (DOUT), LED59.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_60: LED59.4 (DOUT), LED60.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_61: LED60.4 (DOUT), LED61.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_62: LED61.4 (DOUT), LED62.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_63: LED62.4 (DOUT), LED63.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_64: LED63.4 (DOUT), LED64.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_65: LED64.4 (DOUT), LED65.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_66: LED65.4 (DOUT), LED66.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_67: LED66.4 (DOUT), LED67.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_68: LED67.4 (DOUT), LED68.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_69: LED68.4 (DOUT), LED69.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_70: LED69.4 (DOUT), LED70.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_71: LED70.4 (DOUT), LED71.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_72: LED71.4 (DOUT), LED72.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_73: LED72.4 (DOUT), LED73.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_74: LED73.4 (DOUT), LED74.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_75: LED74.4 (DOUT), LED75.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_76: LED75.4 (DOUT), LED76.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_77: LED76.4 (DOUT), LED77.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_78: LED77.4 (DOUT), LED78.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_79: LED78.4 (DOUT), LED79.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_80: LED79.4 (DOUT), LED80.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_81: LED80.4 (DOUT), LED81.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_82: LED81.4 (DOUT), LED82.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_83: LED82.4 (DOUT), LED83.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_84: LED83.4 (DOUT), LED84.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_85: LED84.4 (DOUT), LED85.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_86: LED85.4 (DOUT), LED86.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_87: LED86.4 (DOUT), LED87.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_88: LED87.4 (DOUT), LED88.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_89: LED88.4 (DOUT), LED89.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_90: LED89.4 (DOUT), LED90.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_91: LED90.4 (DOUT), LED91.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_92: LED91.4 (DOUT), LED92.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_93: LED92.4 (DOUT), LED93.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_94: LED93.4 (DOUT), LED94.2 (DIN)
RGB（95 颗 SK6812MINI-E 数据链）/LED_DIN_95: LED94.4 (DOUT), LED95.2 (DIN)
VLED: LED1.3 (VDD), LED2.3 (VDD), LED3.3 (VDD), LED4.3 (VDD), LED5.3 (VDD), LED6.3 (VDD), LED7.3 (VDD), LED8.3 (VDD), LED9.3 (VDD), LED10.3 (VDD), LED11.3 (VDD), LED12.3 (VDD), LED13.3 (VDD), LED14.3 (VDD), LED15.3 (VDD), LED16.3 (VDD), LED17.3 (VDD), LED18.3 (VDD), LED19.3 (VDD), LED20.3 (VDD), LED21.3 (VDD), LED22.3 (VDD), LED23.3 (VDD), LED24.3 (VDD), LED25.3 (VDD), LED26.3 (VDD), LED27.3 (VDD), LED28.3 (VDD), LED29.3 (VDD), LED30.3 (VDD), LED31.3 (VDD), LED32.3 (VDD), LED33.3 (VDD), LED34.3 (VDD), LED35.3 (VDD), LED36.3 (VDD), LED37.3 (VDD), LED38.3 (VDD), LED39.3 (VDD), LED40.3 (VDD), LED41.3 (VDD), LED42.3 (VDD), LED43.3 (VDD), LED44.3 (VDD), LED45.3 (VDD), LED46.3 (VDD), LED47.3 (VDD), LED48.3 (VDD), LED49.3 (VDD), LED50.3 (VDD), LED51.3 (VDD), LED52.3 (VDD), LED53.3 (VDD), LED54.3 (VDD), LED55.3 (VDD), LED56.3 (VDD), LED57.3 (VDD), LED58.3 (VDD), LED59.3 (VDD), LED60.3 (VDD), LED61.3 (VDD), LED62.3 (VDD), LED63.3 (VDD), LED64.3 (VDD), LED65.3 (VDD), LED66.3 (VDD), LED67.3 (VDD), LED68.3 (VDD), LED69.3 (VDD), LED70.3 (VDD), LED71.3 (VDD), LED72.3 (VDD), LED73.3 (VDD), LED74.3 (VDD), LED75.3 (VDD), LED76.3 (VDD), LED77.3 (VDD), LED78.3 (VDD), LED79.3 (VDD), LED80.3 (VDD), LED81.3 (VDD), LED82.3 (VDD), LED83.3 (VDD), LED84.3 (VDD), LED85.3 (VDD), LED86.3 (VDD), LED87.3 (VDD), LED88.3 (VDD), LED89.3 (VDD), LED90.3 (VDD), LED91.3 (VDD), LED92.3 (VDD), LED93.3 (VDD), LED94.3 (VDD), LED95.3 (VDD); also elsewhere on the board

Notes on the sheet:
StarShield RGB 子图 —— 由 docs/_tools/gen_rgb_sch.py 自动生成，请勿手改；改电路请改 docs/_tools/rgb_design.py。依据：ADR-0007（电池直供不升压）、ADR-0005（门控拓扑 C）、ADR-0006（95 键）
【数据链】LED1.DIN = LED_DIN（来自控制子图 J3A 孔2 = nice!nano D1/P0.06，&spi3 MOSI）；LEDi.DOUT → LED(i+1).DIN 依次串联到 LED95；LED95.DOUT 悬空（链尾）。链序 = 键位 index 顺序（行优先、行内从左到右），与 ZMK 侧 LED index 一致
【供电】全部灯珠的 VDD 接 VLED —— 电源子图中由电池直供、经 Q1(AO3401A) PMOS 门控的 LED 轨（ADR-0007：不加 5V 升压；ADR-0005：拓扑 C，MCU 经 2N7002 反相级控制）。VLED 按 2-3 A 走线；固件侧 CONFIG_ZMK_RGB_UNDERGLOW_BRT_MAX=30 是电流护栏（30% 灰阶约 1.0 A）
【静态电流】实测 0.6 mA/颗 x 95 ≈ 57 mA ⇒ 必须物理切断：RGB 关闭 / 深度睡眠时 Q1 关断，LED 轨无电。门控极性 GPIO_ACTIVE_HIGH（经反相级后非反相）
【封装与贴装】LED_SMD:LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm（正装）。⚠️ UNVERIFIED：官方库另一个变体是 ReverseMount（3.2x2.8，灯珠在 PCB 背面、光穿 PCB 开孔），本项目按常规 per-key 做法选正装 —— 投板前（B3/B4）需用实物核对型号-封装对应与贴装方向
【图面说明】本图按「行内顺序」排列灯珠（列间距 25.4 / 行间距 38.1），不是真实物理坐标；PCB 布局（B4）按 sketch/keyboard-layout.json 的 KLE 坐标精确生成。每颗灯珠的 Value 是该键的键帽标签，与 docs/_generated/matrix.json 的 index 一一对应

Board: 4 copper layers, 374.7 x 151.1 mm, 321 parts (0 on the bottom side), 239 nets.

Other parts of the board:
H1, H2, H3, H4, H5, H6, H7, H8: M2; MountingHole_2.2mm_M2

## Code that names these connections

File firmware/boards/shields/starshield/starshield.overlay (part):

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 * 矩阵：6 行 × 18 列，95 键，每个键一颗 1N4148W 二极管，col2row
 * 列驱动：3 颗 74HC595 级联（ZMK 官方 zmk,gpio-595 驱动）
 *   ⚠️ 2026-09-18 修订：原「2 颗」是电气错误 —— 2 颗只有 16 个输出位，驱动不了 18 列；
 *      ngpios=24 时驱动每轮移 24 个时钟，bit16/17 被推出链尾丢失 ⇒ COL16/17（小键盘区）失灵。
 *      位序依据 gpio_595.c：bit0..7 = 第 1 颗 QA..QH、bit8..15 = 第 2 颗、bit16..23 = 第 3 颗。
 * RGB：95 颗 SK6812MINI-E，数据链首颗数据线走 spi3（ZMK 官方做法）
 *
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 *   - 官方要求：595 的 ngpios 只能取 8/16/24/32 → 18 列需 **3 颗**级联（24 位链、用前 18 位）
 *   - 595 与 WS2812 必须用【不同】SPI 外设（两者都是 SPI 从设备）
 *       595   → &spi1（MOSI P0.10 / SCK P1.13；**MISO 已在本 shield 覆盖掉** ——
 *               板级默认把 MISO 放在 P1.11 = D14，与 C1 的三档开关 MODE1 冲突，见下方 &pinctrl）
 *       WS2812 → &spi3（MOSI P0.06）
 *   - P0.13 是 nice!nano 的 VCC 门控脚（置高切断 VCC），官方就是这么省 LED 静态功耗的
 *   - 三档模式开关（C1）：D2(P0.17) / D14(P1.11) / D18(P1.15) = MODE0/MODE1/MODE2
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           视觉顺序（左→右 = 2.4G / 蓝牙 / 有线）由 SW96 的 rot=180 决定，
           推算见本文件顶部的「物理档位顺序」注释。 */
        input-gpios
            = <&pro_micro 2  GPIO_ACTIVE_LOW>   /* 档 0：有线  = MODE0 = D2  (P0.17) */
            , <&pro_micro 14 GPIO_ACTIVE_LOW>   /* 档 1：蓝牙  = MODE1 = D14 (P1.11) */
            , <&pro_micro 18 GPIO_ACTIVE_LOW>   /* 档 2：2.4G  = MODE2 = D18 (P1.15) */
            ;
    };

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        #gpio-cells = <2>;
        reg = <0>;
        spi-max-frequency = <200000>;
        ngpios = <24>;      /* 3 颗 74HC595 级联（24 位链，用前 18 位驱动 COL0..17） */
    };
};

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
File docs/_tools/control_design.py (part):

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    "J3A.9": "ROW1",        # D5    / P0.24
    "J3A.10": "ROW2",       # D6/A7 / P1.00
    "J3A.11": "ROW3",       # D7    / P0.11
    "J3A.12": "ROW5",       # D8/A8 / P1.04 —— ⚠️ overlay row-gpios 第 6 项是 pro_micro 8
    "J3A.13": "ROW4",       # D9/A9 / P1.06 —— overlay 第 5 项是 pro_micro 9

    # --- J3B（实物孔位 1..13，自 USB 端起）-----------------------------------
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     "~SRCLR 接 VCC（不复位）、~OE 接 GND（输出常使能）。"
     "位序依据 ZMK gpio_595.c：SPI MSB first，先移出的位最终在链尾"),
    (25.4, 203.2,
     "【三档开关】SP3T PCM13，公共端(pin3)接 GND，三个掷点接 MODE0/1/2。"
     "ZMK 用 toggle-mode + sideband 读取（GPIO_ACTIVE_LOW，DT 不写 pull —— 驱动管理）。"
     "档 0 = 有线（USB 输出）；档 1 = 蓝牙直连主机（配对位 0）；档 2 = 2.4G（配对位 1 连 Dongle）。"
     "开关 GPIO 定案 D2(P0.17) / D14(P1.11) / D18(P1.15)：保留 D0(UART 语义)、"
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    (25.4, 241.3,
     "【投板前核对】1) nice!nano 排针 pitch/脚数已由 B6 实物核对（每排 13 孔，已改 1x13）"
     "2) PCM13 封装 pad 与符号掷点对应（B3/B4）"
     "3) J3A.12/13 = ROW5/ROW4 的交错顺序与 overlay row-gpios 一一对应（已按 overlay 核实，"
     "但 PCB 布局时仍需复核）4) 排针针径与母座孔径、第五项：USB 口伸出量决定外壳开孔"),
]

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
File docs/_tools/power_design.py (part):

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
    # --- 充电指示 ----------------------------------------------------------
    "R6.1": "OUT", "R6.2": "CHG_LED_A",
    "D96.1": "nCHG", "D96.2": "CHG_LED_A",   # Device:LED  pin1=K  pin2=A

    # --- RGB 门控 ----------------------------------------------------------
    # 控制链：GPIO(HIGH) → R8 → Q2(G) 导通 → Q1(G) 被拉到 GND → Vgs=-V(OUT) → Q1 导通 → VLED 得电
    #         GPIO 未初始化/低 → R9 下拉 Q2 截止 → R7 把 Q1 栅极拉到 OUT → Vgs=0 → 关断
    "R8.1": "RGB_PWR_EN", "R8.2": "Q2_G",
    "R9.1": "Q2_G", "R9.2": "GND",
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    (25.4, 200.66,
     "【门控拓扑 C（ADR-0005，照抄 kurtis-lew/Conejo）】Q1 的 S 必须接电源轨 OUT、D 接负载轨 VLED —— "
     "P-MOS 体二极管阳极在 D，反接会让 LED 轨经体二极管常通，门控失效。"
     "ZMK 侧 ext-power 用 GPIO_ACTIVE_HIGH。控制链：GPIO 高 -> Q2 导通 -> Q1 栅极拉低 -> VLED 得电"),
    (25.4, 209.55,
     "【本版留空 / 未决项】USB-C 的 D+ D- SBU1 SBU2 全部 NC（J1 只做充电 —— "
     "nRF52840 的 USB 是独立专用引脚，nice!nano 排针上无引出）；"
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